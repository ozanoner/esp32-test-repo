## sdkconfig.defaults
```kconfig
CONFIG_LOG_DEFAULT_LEVEL_ERROR=y
CONFIG_LOG_DEFAULT_LEVEL=1
# CONFIG_COMPILER_STATIC_ANALYZER=y
```
